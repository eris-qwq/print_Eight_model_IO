# Keil uVision project print_Eight_model_IO.uvprojx, settings and files
target print_Eight_model_IO (6140001::V6.14.1::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: print_Eight_model_IO +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..;..\Core\Inc;..\BSP;..\APP;..\Task;$(MSPM0_SDK_DIR)\source\third_party\CMSIS\Core\Include;$(MSPM0_SDK_DIR)\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: $(MSPM0_SDK_DIR)\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Core
    ../: empty.syscfg
    ./: startup_mspm0g350x_uvision.s
    ../Core/Src/: ti_msp_dl_config.c main.c
    ../Core/Inc/: ti_msp_dl_config.h
  group BSP
    ../BSP/: bsp_at8236.c bsp_enconder.c bsp_usart.c bsp_delay.c
  group APP
    ../APP/: app_motor.c app_irtracking.c app_usart.c
  group Task
    ../Task/: app_main.c app_main.h
